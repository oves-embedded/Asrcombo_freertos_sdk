# Keil uVision project asr_template.uvprojx, settings and files
target Target 1 (ARM-GNU)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: asr_template +hex
  AfterMake: .\utils\genbinary.bat
